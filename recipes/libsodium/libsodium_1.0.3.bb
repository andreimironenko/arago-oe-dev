require libsodium.inc

SRC_URI[md5sum] = "b3bcc98e34d3250f55ae196822307fab"
SRC_URI[sha256sum] ="cbcfc63cc90c05d18a20f229a62c7e7054a73731d0aa858c0517152c549b1288"
